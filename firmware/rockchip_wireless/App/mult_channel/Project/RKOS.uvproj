# Keil uVision project RKOS.uvproj, settings and files
target RKOS_MCHANNEL (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: RKOS_SRC
  AfterMake: fromelf.exe --bin -o RKNANO.bin A_CORE\RKOS_SRC.axf
  c flags: Optim=3 OneElfS=1 wLevel=1
  c define: _NANOD_
  c misc: --c99
  c include: ..;..\Scatter;..\..\..\Bsp;..\..\..\Cpu;..\..\..\Driver;..\..\..\Driver\Key;..\..\..\Driver\Uart;..\..\..\Gui;..\..\..\OS;..\..\..\System;..\..\..\OS\Include;..\..\..\OS\Portable;..\..\..\OS\Source;..\..\..\OS\Portable\RVDS;..\..\..\Driver\AD;..\..\..\Driver\Key;..\..\..\Driver\AD;..\..\..\Driver\LCD;..\..\..\Driver\SdMmc;..\..\..\Driver\EMMC;..\..\..\Driver\LUN;..\..\..\Driver\Volume;..\..\..\Driver\Partion;..\..\..\Driver\USB;..\..\..\Driver\I2C;..\..\..\Driver\I2S;..\..\..\Driver\Msc;..\..\..\Driver\File;..\..\..\Driver\ALC5633;..\..\..\Driver\ROCKCODEC;..\..\..\Driver\DMA;..\..\..\Driver\Audio;..\..\..\Driver\Example;..\..\..\System\Example;..\Scatter;..\..\..\OS\Plugin;..\..\..\System\SysInfoSave;..\..\..\System\Delay;..\..\..\System\Shell;..\Example;..\..\..\System\Timer;..\..\..\Gui;..\..\..\System\FwAnalysis;..\FileStream;..\Media;..\..\..\Driver\FIFO;..\..\..\Driver\SpiNor;..\..\..\Driver\SPI;..\..\..\Driver\Timer;..\..\..\System\VirtualFile;..\..\..\Driver\Rk903;..\..\..\Driver\Sdio;..\..\..\Driver\Wlc;..\..\..\Wireless;..\..\..\Wireless\Task;..\..\..\Driver\Wlc;..\..\..\System\syssever;..\..\..\Wireless;..\..\..\Wireless\Bcom903;..\..\..\Wireless\Task;..\..\..\Wireless\WebServer;..\..\..\Wireless\Lwip\lwip-1.4.1\src\include;..\..\..\Wireless\Lwip\lwip-1.4.1\src\include\ipv4;..\..\..\Wireless\Lwip\lwip-1.4.1\src\include\lwip;..\..\..\Wireless\Lwip\lwip-1.4.1\src\include\arch;..\..\..\Wireless\Lwip\lwip-1.4.1\src\include\netif;..\..\..\Wireless\Lwip\lwip-1.4.1\src\include\posix;..\..\..\Wireless\Lwip\lwip-1.4.1\src\include\ipv4\lwip;..\..\..\System\DeviceManager;..\..\..\Driver\PWM;..\..\..\Cpu\NanoD;..\..\..\Cpu\NanoD\lib;..\..\EVK_V2.0;..\..\..\Driver\SD;..\..\..\Driver\RK61X;..\..\..\Driver\WM8987;..\..\..\BBSystem;..\..\..\Codecs;..\..\..\Wireless\RKI6000\hal\fw_img\;..\..\..\Wireless\RKI6000\inc;..\..\..\Wireless\RKI6000\osal\freertos;..\..\..\Driver\WatchDog;..\..\..\Driver\MailBox;..\..\..\Driver\USBMsc;..\Audio;..\..\..\Codecs\Audio\Effect;..\..\..\Codecs\Audio\Decode\include;..\..\..\Codecs\Audio\Decode\AAC;..\..\..\Codecs\Audio\Decode\APE;..\..\..\Codecs\Audio\Decode\flac;..\..\..\Codecs\Audio\Decode\HIFI\alac;..\..\..\Codecs\Audio\Decode\HIFI\ape;..\..\..\Codecs\Audio\Decode\HIFI\flac;..\..\..\Codecs\Audio\Decode\Mp3;..\..\..\Codecs\Audio\Decode\Ogg;..\..\..\Codecs\Audio\Decode\Wav;..\..\..\Codecs\Audio\Decode\Wma;..\..\..\Driver\MSG;..\..\..\Driver\Bcore;..\..\..\Wireless\WICE\platform;..\..\..\Wireless\WICE\include;..\..\..\Wireless\WICE\WWD\include;..\..\..\Wireless\WICE;..\..\..\Wireless\WICE\mcu\peripherals\inc;..\..\..\Wireless\WICE\RTOS;..\..\..\Wireless\WICE\WWD;..\..\..\Cpu\NanoD\lib;..\..\..\Wireless\WICE\network;..\..\..\Driver\SPIFlash;..\..\..\Wireless\WICE\jni\easy_setup;..\..\..\Driver\Display;..\..\..\Codecs\Audio\Decode\include;..\..\..\Codecs\Audio\Decode\Mp3\libMad;..\..\..\OS\DeviceManager;..\..\..\OS\FwAnalysis;..\..\..\OS\power;..\..\..\Wireless\dlna\CyberLink4C\include;..\..\..\Wireless\dlna\CyberLink4C\std\av\include;..\..\..\Wireless\dlna\CyberLink4C;..\..\..\Wireless\dlna\dlna\include;..\..\..\Wireless\dlna\dlna;..\..\..\Wireless\dlna\expat\lib;..\..\..\Wireless\dlna;..\main_task;..\..\..\Wireless\Airplay;..\..\..\Wireless\Airplay\airplay;..\..\..\Wireless\Airplay\SSL;..\..\..\Wireless\Airplay\SSL\aes;..\..\..\Wireless\Airplay\SSL\md5;..\..\..\Codecs\Audio\Decode\SBC;..\..\..\Driver\Vop;..\..\..\Wireless\bluetooth\;..\..\..\Wireless\bluetooth\lwbt;..\..\..\Wireless\bluetooth\lwbt\a2dp_source;..\..\..\Wireless\bluetooth\lwbt\BLE;..\..\..\Wireless\bluetooth\lwbt\chipset_rtk8761a;..\..\..\Wireless\bluetooth\lwbt\chipset_cc2564;..\Resource;..\..\..\Wireless\MbedTLS\include;..\..\..\System\UsbServer;..\..\..\Wireless\MbedTLS\include\mbedtls;..\music;..\..\..\Wireless\Lwip\utilities;..\USB;..\SystemSet;..\..\..\Wireless\RKI6000\hal\fw_img\;..\..\..\Wireless\RKI6000\inc;..\..\..\Wireless\RKI6000\osal\freertos;..\..\..\Wireless\RKI6000\hal;..\..\..\Wireless\RKI6000\spi;..\..\..\Wireless\RKI6000\hal\hal_src;..\..\..\Wireless\RKI6000\osal\;..\..\..\Wireless\RKI6000\cmn\;..\..\..\Wireless\RKI6000\wpa_s\;..\..\..\Wireless\Lwip\lwip-1.4.1\port;..\Browser;..\..\..\Wireless\channels;..\Record;..\MediaLibrary;..\..\..\Codecs\Audio\Encode\include;..\..\..\Codecs\Audio\Effect\EQ;..\..\..\Codecs\Audio\Effect\Spectrum;..\..\..\Codecs\Audio\Effect\Fade;..\..\..\Codecs\Audio\Encode\Wav;..\..\..\Codecs\Audio\ID3;..\..\..\Driver\FM
  library: MicroLIB
  memory RVCT1: ROM 0x1000000 size 0x20000
  memory RVCT6: RAM 0x3000000 size 0x20000
  scatter file: ..\Scatter\scatter.sct
  link misc: --keep ModuleInfo --keep bass_60_tbl --keep bass_120_tbl  --keep Eq_Table --entry link_main
  group App
    ../Audio/: AudioControlTask.c
    ../Media/: MediaTask.c
    ../FileStream/: FileStreamTask.c StreamControlTask.c
    ../main_task/: main_task.c
  group Bsp
    ../Scatter/: ScatterLoader.c
    ../: Main.c Bsp.c
  group cpu
    ../../../Cpu/NanoD/: Cortex-m3.S Start.s
    ../../../Cpu/NanoD/lib/: adc.c dma.c gpio.c hifi.c hifi_alac.c hifi_flac.c hifi_ape.c hifi_mac.c hifi_fft.c hw_mp3_imdct.c hw_mp3_syn.c i2c.c I2s.c interrupt.c mailbox.c nvic.c pmu.c pwm.c rockcodec.c sdmmc.c Spi.c systick.c time.c uart.c usb.c vop.c yuv2rgb.c dma2.c cru.c grf.c SFC.c pmc.c
  group Driver
    ../../../Driver/Key/: KeyDevice.c
    ../../../Driver/AD/: AdcDevice.c
    ../../../Driver/Uart/: UartDevice.c
    ../../../Driver/SdMmc/: SdMmcDevice.c
    ../../../Driver/EMMC/: EmmcDevice.c
    ../../../Driver/LUN/: LUNDevice.c
    ../../../Driver/Volume/: FATDevice.c
    ../../../Driver/Partion/: PartionDevice.c
    ../../../Driver/I2C/: I2cDevice.c
    ../../../Driver/I2S/: I2sDevice.c
    ../../../Driver/File/: FileDevice.c DirDevice.c
    ../../../Driver/ROCKCODEC/: RockCodecDevice.c
    ../../../Driver/DMA/: DmaDevice.c
    ../../../Driver/Audio/: AudioDevice.c
    ../../../Driver/FIFO/: FIFODevice.c
    ../../../Driver/SPI/: SpiDevice.c
    ../../../Driver/Timer/: TimerDevice.c
    ../../../Driver/Sdio/: SdioDevice.c
    ../../../Driver/USB/: UsbOtgDev.c
    ../../../Driver/PWM/: PwmDevice.c
    ../../../Driver/SD/: SdDevice.c
    ../../../Driver/WatchDog/: WatchDogDevice.c
    ../../../Driver/MailBox/: MailBoxDevice.c
    ../../../Driver/USBMsc/: UsbMscDevice.c
    ../../../Driver/SPIFlash/: SpiFlashDev.c
    ../../../Driver/Display/: DisplayDevice.c
    ../../../Driver/MSG/: MsgDevice.c
    ../../../Driver/Bcore/: BcoreDevice.c
    ../../../Driver/Vop/: VopDevice.c
    ../../../Driver/FM/: FmDevice.c hw_fm5807.c
    ../../../Driver/LCD/: LCDDriver.c ST7735SDriver.c
  group OS
    ../../../OS/Portable/RVDS/: port.c
    ../../../OS/Source/: croutine.c list.c queue.c tasks.c timers.c heap_4.c
    ../../../OS/Plugin/: TaskPlugin.c device.c RKOS.c
    ../../../OS/DeviceManager/: DeviceManagerTask.c
    ../../../OS/power/: SysResume.c SysSuspend.c
    ../../../OS/FwAnalysis/: FwAnalysis.c FwUpdate.c
  group System
    ../../../System/Delay/: Delay.c
    ../../../System/Shell/: ShellCustomCmd.c ShellDevCmd.c ShellTask.c ShellTaskCmd.c ShellSysCmd.c
    ../../../System/VirtualFile/: VirtualFile.c
    ../../../System/syssever/: PowerManager.c
    ../../../System/UsbServer/: UsbService.c
    ../../../System/SysInfoSave/: SysInfoSave.c
  group GUI
    ../../../Gui/: GUITask.c GUIIcon.c GUIManager.c GUIImage.c GUISelect.c GUIText.c GUIChain.c GUIMsgBox.c GUIProgressBar.c GUISpectrum.c
  group Lwip
    ../../../Wireless/Lwip/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Wireless/Lwip/lwip-1.4.1/src/arch/: sys_arch.c
    ../../../Wireless/Lwip/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c timer.c
    ../../../Wireless/Lwip/lwip-1.4.1/src/core/ipv4/: icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../Wireless/Lwip/lwip-1.4.1/src/netif/: etharp.c slipif.c
    ../../../Wireless/Lwip/utilities/: ip_shell.c ping.c
    ../../../Wireless/Lwip/lwip-1.4.1/port/: dhcpd.c
  group WebSever
    ../../../Wireless/WebServer/: cgi.c fs.c httpd.c httpd_cgi_ssi.c
    ../../../Wireless/WICE/: web_httpd.c
  group WICE
    ../../../Wireless/WICE/: wwd_SDIO.c http.c wifithread.c
    ../../../Wireless/WICE/internal/: waf.c wifi.c system_monitor.c
    ../../../Wireless/WICE/network/: wiced_network.c wiced_network_common.c
    ../../../Wireless/WICE/platform/: wiced_platform_common.c platform_mcu_powersave.c platform_watchdog.c platform_resource.c
    ../../../Wireless/WICE/RTOS/: wiced_rtos_common.c wiced_rtos.c wwd_rtos.c
    ../../../Wireless/WICE/WWD/internal/: wwd_management.c wwd_sdpcm.c wwd_wifi.c wwd_platform_common.c wwd_thread.c wwd_internal.c wwd_resources.c wwd_platform.c
    ../../../Wireless/WICE/WWD/internal/chip/43362A2/: wwd_ap.c 43362A2_bin.c wwd_chip_specific_functions.c
    ../../../Wireless/WICE/network/WWD/: wwd_buffer.c wwd_network.c
    ../../../Wireless/WICE/TLV/: tlv.c
    ../../../Wireless/WICE/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c
    ../../../Wireless/WICE/WWD/internal/bus_protocols/: wwd_bus_common.c
    ../../../Wireless/WICE/jni/: easy_setup_wiced.c
    ../../../Wireless/WICE/jni/easy_setup/: easy_setup.c
    ../../../Wireless/WICE/jni/proto/: akiss.c changhong.c cooee.c neeze.c
  group APE
    ../../../Codecs/Audio/Decode/ape/: apedec.c
  group FLAC
    ../../../Codecs/Audio/Decode/flac/: pFLAC.c
  group WAV
    ../../../Codecs/Audio/Decode/Wav/WAV_LIB/: pWAV_lib.c wav_ImaDecoder.c wav_msadpcm_dec.c
    ../../../Codecs/Audio/Decode/Wav/: pWAV2.c pWAV.c
  group MP3
    ../../../Codecs/Audio/Decode/Mp3/: pMP3.c
  group AAC
    ../../../Codecs/Audio/Decode/AAC/lib/aac_gen_table/: aac_load_table.c aac_table.c aac_table_rom.c
    ../../../Codecs/Audio/Decode/AAC/lib/: aac_aacdec.c aac_aactabs.c aac_assembly.c aac_bitstream.c aac_buffers.c aac_dct4.c aac_decelmnt.c aac_dequant.c aac_fft.c aac_filefmt.c aac_huffman.c aac_hufftabs.c aac_imdct.c aac_MovFile.c aac_movparserinterface.c aac_noiseless.c aac_pns.c aac_stproc.c aac_tns.c aac_trigtabs.c
    ../../../Codecs/Audio/Decode/AAC/: pAAC2.c pAAC.c
  group OGG
    ../../../Codecs/Audio/Decode/Ogg/lib/: ogg_bitwise.c ogg_codebook.c ogg_dsp.c ogg_floor_lookup.c ogg_floor0.c ogg_floor1.c ogg_framing.c ogg_info.c ogg_mapping0.c ogg_mdct.c ogg_misc.c ogg_res012.c ogg_vorbisfile.c
    ../../../Codecs/Audio/Decode/Ogg/: pOGG2.c pOGG.c
  group HIFI_APE
    ../../../Codecs/Audio/Decode/HIFI/ape/: p_hifi_Ape.c
  group HIFI_FLAC
    ../../../Codecs/Audio/Decode/HIFI/flac/: p_hifi_flac.c
  group HIFI_ALAC
    ../../../Codecs/Audio/Decode/HIFI/alac/: p_hifi_alac.c
  group WAV_ENC
    ../../../Codecs/Audio/Encode/Wav/: pWAVEnc.c
  group SBC
    ../../../Codecs/Audio/Decode/SBC/: PsbcFunc.c
  group audio
    ../../../Codecs/Audio/: audio_bcore_bin.c pCODECS.c
    ../Audio/: music.c
    ../../../Codecs/Audio/Effect/EQ/: Effect.c RK_EQ_20160518.lib
    ../../../Codecs/Audio/Effect/Spectrum/: RkNano_Spectrum_V09_0420.lib
    ../Record/: record.c
  group MBEDTLS
    ../../../Wireless/MbedTLS/: rk_tls_heap.c
    ../../../Wireless/MbedTLS/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group channel
    ../../../Wireless/channels/: rk_fochannel.c
